# Keil uVision project INET_Project.uvprojx, settings and files
target INET_Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: INET_Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal.c stm32l1xx_hal_spi.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_tim.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_tim_ex.c
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32l152xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
